# IAR project 0.96_OLED_SPI.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: SPI; OLED; USER; SYSTEM
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  group HARDWARE
    OLED/: oled.c oled.h
    SPI/: SPI.c SPI.h
  group SYSTEM
    SYSTEM/: delay.c delay.h type.h
  group USER
    USER/: bmp.h gui.c gui.h main.c oledfont.h test.c test.h
