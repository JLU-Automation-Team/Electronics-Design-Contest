# Keil uVision project OLED.uvproj, settings and files
target OLED (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: TEST_OLED +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\FONT;..\GUI;..\HARDWARE\OLED;..\HARDWARE\SPI;..\SYSTEM;..\TEST;..\USER
  group USER
    ../USER/: main.c
    ../GUI/: gui.c
    ../TEST/: test.c
  group SYSTEM
    ../SYSTEM/: sys.c
  group HARDWRE
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/SPI/: spi.c
